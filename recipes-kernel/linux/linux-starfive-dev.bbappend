KERNEL_SPLIT_MODULES = "0"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://no_suspend.cfg"

